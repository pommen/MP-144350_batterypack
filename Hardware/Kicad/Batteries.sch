File: Hardware/Kicad/Batteries.sch (KiCad schematic (older format))
At the start: 54 parts

Commit message: Add files via upload
Other:
- moved on the sheet: BT?, C?, Q?, R?, U?
